Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-11-11T18:12:18
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy (10)
In: Default Building Storey
Description: Description of Object
