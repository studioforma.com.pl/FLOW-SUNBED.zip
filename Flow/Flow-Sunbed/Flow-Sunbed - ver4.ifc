Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Flow-Sunbed - ver4.ifc
Time: 2025-11-11T18:12:06
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (10)
Name
 | Flow-Sunbed_0 - ObjectType: SketchupGroup
 | Flow-Sunbed_1 - ObjectType: SketchupGroup
 | Flow-Sunbed_2 - ObjectType: SketchupGroup
 | Flow-Sunbed_3 - ObjectType: SketchupGroup
 | Flow-Sunbed_4 - ObjectType: SketchupGroup
 | Flow-Sunbed_5 - ObjectType: SketchupGroup
 | Flow-Sunbed_6 - ObjectType: SketchupGroup
 | Flow-Sunbed_7 - ObjectType: SketchupGroup
 | Flow-Sunbed_8 - ObjectType: SketchupGroup
 | Flow-Sunbed_9 - ObjectType: SketchupGroup
